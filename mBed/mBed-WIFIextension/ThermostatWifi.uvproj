# Keil uVision project ThermostatWifi.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ThermostatWifi
  AfterMake: fromelf --bin -o build\ThermostatWifi_LPC1768.bin build\ThermostatWifi.axf
  c flags: Optim=1
  c define: TARGET_LPC1768,  TARGET_M3,  TARGET_NXP,  TARGET_LPC176X,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,
  c misc: --gnu
  c include: .;  mbed;  mbed/LPC1768;  mbed/LPC1768/ARM;  MODSERIAL;  Wifly-RX_XV;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/LPC1768/ARM/LPC1768.sct
  link misc: mbed/LPC1768/ARM/sys.o
                 
                mbed/LPC1768/ARM/cmsis_nvic.o
                 
                mbed/LPC1768/ARM/system_LPC17xx.o
                 
                mbed/LPC1768/ARM/core_cm3.o
                 
                mbed/LPC1768/ARM/startup_LPC17xx.o
                 
                mbed/LPC1768/ARM/mbed.ar
  group src
    MODSERIAL/: ChangeLog.c FLUSH.cpp example_dma.cpp example2.cpp MODSERIAL.cpp example3a.cpp GETC.cpp ISR_TX.cpp example1.cpp INIT.cpp MODSERIAL_IRQ_INFO.cpp PUTC.cpp RESIZE.cpp ISR_RX.cpp example3b.cpp
    ./: main.cpp
    Wifly-RX_XV/: WiflyModule.cpp
